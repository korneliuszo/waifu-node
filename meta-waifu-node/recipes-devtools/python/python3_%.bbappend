SYSROOT_DIRS += " ${bindir} "