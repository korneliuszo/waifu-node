# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)

# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=74420fc3965c4558a4a1529e63c2867f"

SRC_URI[sha256sum] = "30d36967ccaded5cbb38d602c433f53600036c79d502f4533a49b60a03bbefcd"

inherit pypi python_flit_core

PYPI_PACKAGE = "truststore"
