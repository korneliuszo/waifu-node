# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)

# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=301b62ec6f5639ce12542b8570baf3f0"

inherit python_pdm

SRC_URI = "git://github.com/promplate/partial-json-parser;protocol=https;nobranch=1"
SRCREV = "8e83b92d6f92a0a87b611792a9eab0f5bf0fda64"
