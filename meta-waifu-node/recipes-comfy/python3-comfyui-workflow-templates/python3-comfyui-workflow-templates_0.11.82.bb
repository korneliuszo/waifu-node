include python3-comfyui-workflow-templates.inc

RDEPENDS:${PN} += " \
    python3-comfyui-workflow-templates-core \
    python3-comfyui-workflow-templates-json \
    python3-comfyui-workflow-templates-media-api \
    python3-comfyui-workflow-templates-media-video \
    python3-comfyui-workflow-templates-media-image \
    python3-comfyui-workflow-templates-media-other \
    python3-comfyui-workflow-templates-media-assets-01 \
    python3-comfyui-workflow-templates-media-assets-02 \
"

